# Keil uVision project pino_stm32.uvprojx, settings and files
target pino_stm32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PINO_STM32 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CMSIS;..\LIB\inc;..\LIB\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c system_stm32f10x.c system.c delay.c fm_se.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c
  group STARTUPCODE
    ../CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c
